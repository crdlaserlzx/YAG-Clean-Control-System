# Keil uVision project LaserClean.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LaserClean +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE;..\CORE;..\OBJ;..\STM32F10x_FWLib;..\SYSTEM;..\USER;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\delay;..\STM32F10x_FWLib\src;..\STM32F10x_FWLib\inc;..\HARDWARE\EXTI;..\HARDWARE\LCD;..\HARDWARE\SCAN;..\HARDWARE\AD5722R;..\HARDWARE\RA8875;..\HARDWARE\FlashStorage;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\control_gpio
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group HARDWARE
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/LCD/: LCD.c
    ../HARDWARE/SCAN/: scan.c
    ../HARDWARE/AD5722R/: AD5722R.c
    ../HARDWARE/RA8875/: RA8875.c
    ../HARDWARE/FlashStorage/: FlashStorage.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/control_gpio/: control_gpio.c
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
